# Keil uVision project Lab4C.uvproj, settings and files
target getWeather (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: getWeather
  AfterMake: fromelf --bin --output .\rvmdk\cc31000_starter.bin .\rvmdk\cc31000_starter.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM _POSIX_SOURCE UART_BUFFERED TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..;..\;..\..\..\..;..\cc3100;..\cc3100\platform\ek-tm4c123gxl;..\cc3100\simplelink\include;..\cc3100\simplelink\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: cc31000_starter.sct
  link misc: --entry Reset_Handler
  group Source
    ./: main.c Nokia5110.c LED.c startup_rvmdk.S ADCSWTrigger.c ADCSWTrigger.h tm4c123gh6pm.h simplelink.h fs.h LED.h netapp.h netcfg.h Nokia5110.h readme.txt socket.h trace.h wlan.h wlan_rx_filters.h startup_ccs.c startup_ewarm.c startup_gcc.c tm4c123gh6pm_startup_ccs.c application_commands.h ccs_proj_args.txt datatypes.h device.h driver.h filelist.txt flowcont.h nonos.h objInclusion.h protocol.h spawn.h board.h spi.h uart.h uartstdio.h user.h ustdlib.h tm4c123gh6pm_startup_ccs.h
    ./: board.c device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c spi.c uart.c wlan.c uartstdio.c ustdlib.c
  group Libraries
    ./: driverlib.lib
  group Documentation
    ./: readme.txt
