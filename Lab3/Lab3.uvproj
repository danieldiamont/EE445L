# Keil uVision project Lab3.uvproj, settings and files
target ADCSWTrigger (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCSWTrigger
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ADCSWTrigger.c PLL.c main.c tm4c123gh6pm.h ST7735.h ST7735.c LCD.s Print.s fixed.c fixed.h gpio.c gpio.h sevensegment.c sound.c switches.c sevensegment.h sound.h switches.h timer.c timer.h clock.c clock.h
    ./driverlib/: debug.h interrupt.h pin_map.h sysctl.h systick.h interrupt.c sysctl.c sysexc.c systick.c cpu.c cpu.h comp.c comp.h
    ./inc/: hw_gpio.h hw_ints.h hw_memmap.h hw_nvic.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_comp.h
