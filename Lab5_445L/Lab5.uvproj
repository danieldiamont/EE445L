# Keil uVision project Lab5.uvproj, settings and files
target Lab6 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab6
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Sound.c Lab5.c SysTickInts.c Sound.h SysTickInts.h TExaS.h tm4c123gh6pm.h MAX5353.h MAX5353.c Timer0A.c Timer0A.h Switch.c Timer1A.c Switch.h Timer1A.h
  group Object code
    ./: texas.o
