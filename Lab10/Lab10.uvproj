# Keil uVision project Lab10.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab10
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: LCD.s Print.s startup.s PWM.c PLL.h PWM.h Switch.h tm4c123gh6pm.h ST7735.h ST7735.c PLL.c Switch.c Controller.c Controller.h Lab10.c fixed.c fixed.h UART.c UART.h
