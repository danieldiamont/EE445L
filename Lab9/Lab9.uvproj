# Keil uVision project Lab9.uvproj, settings and files
target Lab6 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab6
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADCT0ATrigger.c FiFo.c Lab9.c PLL.c ST7735.c Switch.c SysTickInts.c startup.s ADCT0ATrigger.h FiFo.h PLL.h ST7735.h Switch.h SysTickInts.h tm4c123gh6pm.h LCD.s Print.s fixed.c fixed.h UART.h UART.c
